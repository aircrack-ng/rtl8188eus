## Kconfig
```kconfig
config RTL8188EUS
	tristate "Realtek 8188E USB WiFi"
	depends on USB
	---help---
	  Help message of RTL8188EUS
```
